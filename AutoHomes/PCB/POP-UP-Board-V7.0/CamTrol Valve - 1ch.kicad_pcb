# Repository camtrol/camtrol (continued)

## KiCad design MS-Harnes/PCB/CarInd-Main-V3.2/CarInd-Main-V3.2.kicad_pcb

Board: 2 copper layers, 122.0 x 100.0 mm, 126 parts (71 on the bottom side), 91 nets.

Parts:
C1: 220uF/10V; CP_Elec_6.3x5.3
C2, C3, C5: 106; C_0805_HandSoldering
C4: 220uF/25V; CP_Radial_D8.0mm_P2.50mm
C6, C7, C8, C9: 104; C_0805_HandSoldering
D1: CPU; LED_0805
D2, D8, D10, D11, D17, D22: RED LED; LED_0805
D3, D14, D15, D16, D19, D26: 4007; D_SOD-123
D4: 인버터; LED_0805
D5: SS34; D_SMA
D6: +12V; LED_0805
D9: 트렁크 도어; LED_0805
D18, D23, D24, D27: 4007; D_SMA
D20: 냉장고; LED_0805
D21: TV; LED_0805
D25: SM712; SOT-23
F1, F2, F3, F4, F5, F6, F7, F8: FRG500-16F; FUSE-PIN-Holder-Mini
J1: 5267-04P; Molex_SPOX_5267-04A_1x04_P2.50mm_Vertical
J2: RJ45_LED; RJ45_LED_SMD
J10: Conn_01x02_Male; 090II-6P
J11: Conn_01x02_Male; 090II-14P
J13, J14: BR-120
K1, K2, K3, K5, K7, K8: DC12V-A; JQC-T78-DC12V-C
MO3: MP1584; TZT-SMD
Q1, Q2, Q6, Q7, Q10, Q11, Q12, Q13: AOD4185; AOD1485
Q3, Q4, Q5, Q8, Q9, Q14, Q15, Q16, Q17, Q18: MMBTA42L; SOT-23
R1, R2, R4, R37, R38, R41, R42, R43: 10KΩ; R_0805_HandSoldering
R3, R35: 330Ω; R_0805_HandSoldering
R5, R8, R9, R11, R14, R16, R17, R20, R21, R25, R26, R27, R29, R33: 2KΩ; R_0805_HandSoldering
R6, R7, R10, R12, R13, R15, R18, R19, R22, R23, R28, R30, R31, R32, R40, R44, R46: 20KΩ; R_0805_HandSoldering
R34: 1KΩ; R_0805_HandSoldering
R36: 100Ω; R_0805_HandSoldering
R45: 120Ω; R_0805_HandSoldering
ST7735S1: Conn_01x12_Male; ST7735S_IPS
SW1: YSS-1203; SW_DIP_SPSTx04_Slide_Copal_CHS-04A_W5.08mm_P1.27mm_JPin
SW2: RESET; TS-3404
SW3, SW6: SW_Push; MP3-2x4x3.5mm-TACT
SW4: NW3-SK-02
SW5: BOOT; TS-3404
U1: 3.3V; SOT-223
U2: ESP32-S3-PCB
U4: 485; MAX485

Connections:
3V3: C1.1, C5.1, R1.1, R2.1, R4.2, R35.2, R36.1, R37.2, R38.2, ST7735S1.10, SW4.2 (B), U2.2 (3V3)
+5V: C3.1, MO3.4 (+5V), R34.1, R41.2, R42.2, R43.2, R46.1, U1.3 (VI), U4.8 (VCC)
+12P: C6.2, C7.2, C8.2, C9.2, D3.2 (K), D5.1 (A), D14.2 (K), D15.2 (K), D16.2 (K), D19.2 (K), D26.2 (K), J2.1, J2.2, J10.5, J13.1, K1.6, K1.7, K2.6, K2.7, K3.6, K3.7, K5.6, K5.7, K7.6, K8.6, Q1.S (Source), Q2.S (Source), Q6.S (Source), Q7.S (Source), Q10.S (Source), Q11.S (Source), Q12.S (Source), Q13.S (Source), R5.1, R10.1, R12.1, R14.1, R20.1, R21.1, R32.1
/485-A: D25.2 (A2), J2.6, R46.2, SW1.2, U4.6 (A)
/485-B: D25.1 (A1), J2.5, R44.1, R45.2, U4.7 (B)
/CANIVAL: SW1.5, U2.11 (IO_18)
/MS: SW1.6, U2.14 (IO_20)
BOOT: R4.1, SW3.2, SW5.2, U2.27 (IO_0)
CIGAR: R29.2, U2.28 (IO_35)
DI: R41.1, U2.6 (IO_6), U4.4 (DI)
EN: C2.1, R2.2, R3.1, U2.3 (EN)
ENABLE: R42.1, U2.5 (IO_5), U4.2 (~RE), U4.3 (DE)
FRIDGE: R26.2, U2.29 (IO_36)
GNDPWR: C1.2, C2.2, C3.2, C4.2, C5.2, C6.1, C7.1, C8.1, C9.1, D1.1 (K), D2.1 (K), D6.1 (K), D8.1 (K), D10.1 (K), D11.1 (K), D17.1 (K), D18.1 (A), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (A), D24.1 (A), D25.3 (common), D27.1 (A), J1.4, J2.3, J2.4, J2.9, J2.11, J2.SH, J10.1, J11.1, J11.3, J11.5, J11.7, J11.9, J14.1, MO3.1 (GND), MO3.3 (GND), Q3.2 (E), Q4.2 (E), Q5.2 (E), Q8.2 (E), Q9.2 (E), Q14.2 (E), Q15.2 (E), Q16.2 (E), Q17.2 (E), Q18.2 (E), R7.2, R13.2, R18.2, R19.2, R44.2, ST7735S1.8, ST7735S1.12, ST7735S1.13, SW1.1, SW1.3, SW1.4, SW2.2, SW3.1, SW3.MP, SW4.4 (C), SW5.1, SW6.1, SW6.MP, U1.1 (GND), U2.1 (GND), U2.40 (GND), U2.41 (GND), U4.5 (GND)
INV: R11.2, U2.31 (IO_38)
IPS-CS: ST7735S1.7, U2.17 (IO_09)
IPS-RESET: ST7735S1.6, U2.18 (IO_10)
IPS-RS: ST7735S1.5, U2.19 (IO_11)
IPS-SCL: R37.1, ST7735S1.4, U2.38 (IO_2)
IPS-SDA: R38.1, ST7735S1.3, U2.35 (TMS/IO_42)
LED_1: R8.2, U2.22 (IO_14)
LED_2: R9.2, U2.23 (IO_21)
LED_3: R16.2, U2.24 (IO_47)
LED_4: R17.2, U2.25 (IO_48)
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R6.2
unnamed: D3.1 (A), D9.1 (K), K7.2, Q18.3 (C)
unnamed: D4.2 (A), R12.2
unnamed: C4.1, D5.2 (K), MO3.2 (+12V)
unnamed: D6.2 (A), R10.2
unnamed: D8.2 (A), R15.2
unnamed: D9.2 (A), R32.2
unnamed: D10.2 (A), R22.2
unnamed: D11.2 (A), R23.2
unnamed: D14.1 (A), K2.2, Q4.3 (C)
unnamed: D15.1 (A), K1.2, Q15.3 (C)
unnamed: D16.1 (A), K3.2, Q17.3 (C)
unnamed: D17.2 (A), R28.2
unnamed: D18.2 (K), F5.2, J10.4, R28.1
unnamed: D19.1 (A), K5.2, Q16.3 (C)
unnamed: D20.2 (A), R30.2
unnamed: D21.2 (A), R31.2
unnamed: D22.2 (A), R40.2
unnamed: D23.2 (K), F8.2, J10.2, R31.1
unnamed: D24.2 (K), F6.2, J10.6, R40.1
unnamed: D4.1 (K), D26.1 (A), K8.2, Q14.3 (C)
unnamed: D27.2 (K), F7.2, J10.3, R30.1
unnamed: F5.1, K3.14
unnamed: F6.1, K2.14
unnamed: F7.1, K1.14
unnamed: F8.1, K5.14
unnamed: J1.1, SW4.3 (C)
unnamed: J2.10, R35.1
unnamed: J2.12, R34.2
unnamed: F4.2, J11.2, R23.1
unnamed: F3.2, J11.4, R22.1
unnamed: F2.2, J11.6, J11.8, R15.1
unnamed: F1.2, J11.10, R6.1
unnamed: J11.11, K7.14
unnamed: J11.12, K7.7
unnamed: J11.13, K8.14
unnamed: J11.14, K8.7
unnamed: F1.1, Q1.D (Drain), Q2.D (Drain)
unnamed: Q1.G (Gate), Q2.G (Gate), Q3.3 (C), R5.2
unnamed: Q3.1 (B), R7.1, R8.1
unnamed: Q4.1 (B), R25.1
unnamed: Q5.1 (B), R9.1, R13.1
unnamed: Q5.3 (C), Q6.G (Gate), Q7.G (Gate), R14.2
unnamed: F2.1, Q6.D (Drain), Q7.D (Drain)
unnamed: Q8.1 (B), R16.1, R18.1
unnamed: Q9.1 (B), R17.1, R19.1
unnamed: F3.1, Q10.D (Drain), Q11.D (Drain)
unnamed: Q8.3 (C), Q10.G (Gate), Q11.G (Gate), R20.2
unnamed: F4.1, Q12.D (Drain), Q13.D (Drain)
unnamed: Q9.3 (C), Q12.G (Gate), Q13.G (Gate), R21.2
unnamed: Q14.1 (B), R11.1
unnamed: Q15.1 (B), R26.1
unnamed: Q16.1 (B), R27.1
unnamed: Q17.1 (B), R29.1
unnamed: Q18.1 (B), R33.1
unnamed: R3.2, SW2.1, SW6.2
unnamed: R45.1, SW1.7
unnamed: R36.2, ST7735S1.11
unnamed: SW4.1 (A), U1.2 (VO)
unnamed: SW1.8, U2.10 (IO_17)
unnamed: R33.2, U2.16 (IO_46)
PUMP: R25.2, U2.26 (IO_45)
RO: R43.1, U2.4 (IO_4), U4.1 (RO)
RxD0: J1.2, U2.36 (RxD0)
TV: R27.2, U2.30 (IO_37)
TxD0: J1.3, U2.37 (TxD0)

## KiCad design Marre/PCB/Marre-Main-V2.2/Marre-Main-V2.2.kicad_pcb

Parts:
AUX_BT1: B3296Y-2KΩ; Potentiometer_Bourns_3296Y_Vertical
C1, C4, C20: 106; C_0805_HandSoldering
C2: 220uF/10V; CP_Elec_6.3x5.3
C3, C7, C9, C10, C11, C13: 104; C_0805_HandSoldering
C5: 220uF/25V; CP_Radial_D8.0mm_P2.50mm
CON_1, CON_2, CON_3: Conn_01x12_Male; 090II-14P
D1: 인버터; LED_0805
D2, D12, D15: 4007; D_SOD-123
D3: 팝업등; LED_0805
D4: 침상등; LED_0805
D5: 사이드; LED_0805
D6: 전면등; LED_0805
D7, D8, D9, D10, D17, D21, D23, D24, D25, D26, D28, D36, D38: 4007; D_SMA
D11: CPU; LED_0805
D13: SS34; D_SMA
D14: 무드등; LED_0805
D16: TV; LED_0805
D18: 어닝등; LED_0805
D19: 후면등; LED_0805
D20: 철재장; LED_0805
D22: 냉장고; LED_0805
D27: MAIN; LED_0805
D29: 리프트 상승; LED_0805
D30: 리프트 하강; LED_0805
D31: 침상 스위치; LED_0805
D32: ACC; LED_0805
D33, D34, D35, D43: 1N4148W; D_SOD-123
D37: 히터; LED_0805
D39: 시거잭 1; LED_0805
D40: 시거잭 2; LED_0805
D41, D46: 시트; LED_0805
D42: 펌프; LED_0805
D44: 인체감지; LED_0805
D45: 물펌프; LED_0805
D47: SM712; SOT-23
F1, F2, F3, F4, F5, F6, F7, F8, F9, F10, F11, F12, F13, F14, F15: FRG500-16F; FUSE-PIN-Holder-Mini
H4, H7, H8: MH; MountingHole_3.2mm_M3-pcb
J1: Conn_01x02_Pin; PhoenixContact_MCV_1,5_2-G-3.81_1x02_P3.81mm_Vertical
J2, J9: 5267-04P; XH2.54-4P
J3, J8, J12: Conn_01x06_Pin; JST_GH_SM06B-GHS-TB_1x06-1MP_P1.25mm_Horizontal
J5: Conn_01x12_Male; IDC-Header_2x07_P2.54mm_Vertical
J6, J7: BR-120
J10: 5267-04P; Molex_SPOX_5267-04A_1x04_P2.50mm_Vertical
J13: Conn_01x08_Pin; JST_GH_SM08B-GHS-TB_1x08-1MP_P1.25mm_Horizontal
J15: RJ45_LED; RJ45_LED_SMD
J22: Conn_01x12_Male; IDC-Header_2x06_P2.54mm_Vertical
JP1: SolderJumper_3_Open; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm
K1: SIP-1B12; Relay_SPST_StandexMeder_SIL_Form1A
K2, K4, K5, K9, K10: JQC-T78-DC12V-C
K3, K6: DC12V-A; JQC-T78-DC12V-C
K7: DC12V-C; JQC-T78-DC12V-C
MO2: ADS1115
MO3: MP1584; MP1584-SMD
MO4: MP1584; TZT-SMD
Q1, Q2, Q3, Q4, Q5, Q6, Q7, Q8, Q18, Q19, Q27, Q28, Q29, Q30, Q33, Q34: AOD4185; AOD1485
Q9, Q10, Q11, Q12, Q13, Q14, Q15, Q16, Q17, Q20, Q21, Q22, Q23, Q26, Q35: MMBT2222A; SOT-23
R1, R3, R6, R10, R19, R21, R22, R23, R24, R25, R32, R34, R37, R38, R39, R42, R43, R44, R45, R46, R47, R48, R49, R50, R53, R55, R56, R57, R58, R59, R60, R61, R62, R63, R67, R68, R69, R70, R71, R72, R73: 20KΩ; R_0805_HandSoldering
R2: 100Ω; R_0805_HandSoldering
R4, R5, R7, R8, R9, R11, R13, R14, R15, R16, R20, R26, R28, R29, R30, R31, R40, R51, R52, R54, R65, R66: 2KΩ; R_0805_HandSoldering
R12, R17, R18, R27, R33, R35, R41, R64, R74, R79: 10KΩ; R_0805_HandSoldering
R36: 120Ω; R_0805_HandSoldering
R76, R77: 1KΩ; R_0805_HandSoldering
R78: 330Ω; R_0805_HandSoldering
SW1: LIFT UP; SMD-SW_6x6x5mm
SW2: LIFT DOWN; SMD-SW_6x6x5mm
SW3: NW3-SK-02
SW5: RESET; TS-3404
SW6: BOOT; TS-3404
TP1, TP2: GND; Test_Point_Keystone_5000-5004_Miniature
U2: 485; MAX485
U4: ESP32-S3
U5: ADS1115IDGS; TSSOP-10_3x3mm_P0.5mm

Connections:
+3.3V: J8.5, J22.B5 (Pin_11), R78.2, SW3.1 (A), U4.21 (3.3V)
+5V: C1.1, C2.1, C3.1, C4.1, J2.1, MO2.VDD, MO4.4 (+5V), R12.2, R17.2, R18.2, R27.2, R33.2, R35.1, R37.1, R41.1, R76.1, SW3.3 (C), U2.8 (VCC), U4.39 (VIN), U5.8 (VDD); also elsewhere on the board
+12P: C7.1, C9.1, C10.1, C11.1, C13.1, D13.1 (A), D35.2 (K), D43.2 (K), F11.1, F12.1, F13.1, F14.1, F15.1, J6.1, J9.1, J15.1, J15.2, JP1.3 (B), K1.3, K4.7, K5.7, K7.6, K7.7, Q1.S (Source), Q2.S (Source), Q3.S (Source), Q4.S (Source), Q5.S (Source), Q6.S (Source), Q7.S (Source), Q8.S (Source), Q18.S (Source), Q19.S (Source), Q27.S (Source), Q28.S (Source), Q29.S (Source), Q30.S (Source), Q33.S (Source), Q34.S (Source), R1.1, R5.1, R9.1, R13.1, R14.1, R15.1, R16.1, R65.1, R66.1, R68.1, R74.2
+VDC: D2.2 (K), D12.2 (K), D15.2 (K), JP1.2 (C), K2.6, K4.6, K5.6, R55.1
/485-A: D47.1 (A1), J9.4, J15.6, R36.1, R37.2, U2.6 (A)
/485-B: D47.2 (A2), J9.3, J15.5, R34.1, R36.2, U2.7 (B)
/ACC: CON_3.9, R63.1, R64.2
/BUNKER 1: CON_3.8, K1.7
/BUNKER 2: CON_3.7, K7.1
/FRIGE +: CON_3.14, D26.2 (K), F10.2, R57.1
/OUT-1 +: CON_1.12, D7.2 (K), F1.2, R19.1
/OUT-2 +: CON_1.10, D8.2 (K), F2.2, R21.1
/OUT-3 +: CON_1.8, D9.2 (K), F3.2, R23.1
/OUT-4 +: CON_1.6, D10.2 (K), F4.2, R25.1
/OUT-5 +: CON_1.4, D23.2 (K), F5.2, R44.1
/OUT-6 +: CON_1.2, D24.2 (K), F6.2, R46.1
/OUT-7 +: CON_2.14, D17.2 (K), F7.2, R6.1
/OUT-8 +: CON_2.12, D21.2 (K), F8.2, R10.1
/TV +: CON_2.2, D25.2 (K), F9.2, R56.1
AUX-V: MO2.A0, R79.1, U5.4 (AIN0); also elsewhere on the board
CLEAN: MO2.A1, U5.5 (AIN1); also elsewhere on the board
Cigar 1: CON_2.6, F12.2, R22.1
Cigar 2: CON_2.4, F13.2, R24.1
DI: R18.1, U2.4 (DI), U4.25 (IO_06)
EN: SW5.1, U4.22 (EN)
ENABLE: R27.1, U2.2 (~RE), U2.3 (DE), U4.24 (IO_05)
FRIGE: D2.1 (A), J5.B4 (Pin_8), J13.5, K5.2, Q13.3 (C)
GNDPWR: AUX_BT1.1, AUX_BT1.2, C1.2, C2.2, C3.2, C4.2, C5.2, C7.2, C9.2, C10.2, C11.2, C13.2, C20.2, CON_1.1, CON_1.3, CON_1.5, CON_1.7, CON_1.9, CON_1.11, CON_2.1, CON_2.11, CON_2.13, CON_3.6, CON_3.13, D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (A), D8.1 (A), D9.1 (A), D10.1 (A), D11.1 (K), D14.1 (K), D16.1 (K), D17.1 (A), D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (A), D22.1 (K), D23.1 (A), D24.1 (A), D25.1 (A), D26.1 (A), D27.1 (K), D31.1 (K), D32.1 (K), D36.1 (A), D37.1 (K), D39.1 (K), D40.1 (K), D41.1 (K), D42.1 (K), D45.1 (K), D47.3 (common), H7.1, J2.2, J3.MP (Pin_1), J5.B7 (Pin_14), J7.1, J8.6, J8.MP (Pin_7), J9.2, J10.4, J12.MP (Pin_1), J13.8, J13.MP (Pin_9), J15.3, J15.4, J15.9, J15.11, J15.SH, J22.B6 (Pin_12), K10.2, MO2.ADDR, MO2.GND, MO3.1 (GND), MO3.3 (GND), MO4.1 (GND), MO4.3 (GND), Q9.2 (E), Q10.2 (E), Q11.2 (E), Q12.2 (E), Q13.2 (E), Q14.2 (E), Q15.2 (E), Q16.2 (E), Q17.2 (E), Q20.2 (E), Q21.2 (E), Q22.2 (E), Q23.2 (E), Q26.2 (E), Q35.2 (E), R2.2, R34.2, R38.2, R42.2, R43.2, R45.2, R47.2, R48.2, R49.2, R50.2, R53.2, R58.2, R59.2, R67.2, R71.2, R72.2, R73.2, SW3.4 (C), SW5.2, SW6.2, U2.5 (GND), U4.20 (GND), U5.1 (ADDR), U5.3 (GND); also elsewhere on the board
HUMAN-SENSOR: J2.3, J2.4, J15.8, R40.2, U4.1 (IO_13)
Heater: CON_3.12, F11.2, R3.1
INVERTER: D1.1 (K), D15.1 (A), J5.B2 (Pin_4), J13.3, K2.2, Q20.3 (C)
IO_0: SW6.1, U4.7 (IO_00)
LED_OUT_01: R28.2, U4.8 (IO_35)
LED_OUT_02: R29.2, U4.9 (IO_36)
LED_OUT_03: R30.2, U4.10 (IO_37)
LED_OUT_04: R31.2, U4.2 (IO_14)
LED_OUT_05: R51.2, U4.3 (IO_21)
LED_OUT_06: R52.2, U4.4 (IO_47)
LED_OUT_07: R8.2, U4.5 (IO_48)
LED_OUT_08: R11.2, U4.6 (IO_45)
LIFT-COM: CON_3.3, K3.7, K6.7, SW1.2, SW2.1
LIFT-DOWN: CON_3.2, K6.14, SW2.2
LIFT-UP: CON_3.1, K3.14, SW1.1
MA-AUTO-IN: C5.1, J5.B6 (Pin_12), J13.7, MO4.2 (+12V)
MA-AUTO-OUT: D13.2 (K), J5.B5 (Pin_10), J13.6, MO3.2 (+12V)
unnamed: AUX_BT1.3, R77.1
unnamed: C20.1, R74.1, R77.2, R79.2
unnamed: D1.2 (A), R55.2
unnamed: D3.2 (A), R19.2
unnamed: D4.2 (A), R21.2
unnamed: D5.2 (A), R23.2
unnamed: D6.2 (A), R25.2
unnamed: D11.2 (A), R35.2
unnamed: D14.2 (A), R6.2
unnamed: D16.2 (A), R56.2
unnamed: D18.2 (A), R10.2
unnamed: D19.2 (A), R44.2
unnamed: D20.2 (A), R46.2
unnamed: D22.2 (A), R57.2
unnamed: D27.2 (A), R1.2
unnamed: D28.1 (A), D38.1 (A), D46.1 (K), K9.2
unnamed: D29.2 (A), R60.2
unnamed: D30.2 (A), R61.2
unnamed: D31.2 (A), R62.2
unnamed: D32.2 (A), R63.2
unnamed: D33.2 (K), D34.2 (K), K1.1, K3.6, K6.6, R60.1, R61.1, R62.1
unnamed: D35.1 (A), K7.2, Q22.3 (C)
unnamed: D37.2 (A), R3.2
unnamed: D39.2 (A), R22.2
unnamed: D40.2 (A), R24.2
unnamed: D41.2 (A), R32.2
unnamed: D42.2 (A), R39.2
unnamed: D43.1 (A), D44.1 (K), K1.5, Q23.3 (C)
unnamed: D44.2 (A), R68.2
unnamed: D45.2 (A), R69.2
unnamed: D46.2 (A), R70.2
unnamed: F9.1, K4.14
unnamed: F10.1, K5.14
unnamed: J1.1, K2.7
unnamed: J1.2, K2.14
unnamed: J10.1, SW3.2 (B)
unnamed: J10.2, U4.16 (RxD0)
unnamed: J10.3, U4.17 (TxD0)
unnamed: J5.A1 (Pin_1), J12.1 (Pin_2), Q1.G (Gate), Q2.G (Gate), Q9.3 (C), R13.2
unnamed: J5.A2 (Pin_3), J12.2 (Pin_3), Q3.G (Gate), Q4.G (Gate), Q10.3 (C), R14.2
unnamed: J5.A3 (Pin_5), J12.3 (Pin_4), Q5.G (Gate), Q6.G (Gate), Q11.3 (C), R15.2
unnamed: J5.A4 (Pin_7), J12.4 (Pin_5), Q7.G (Gate), Q8.G (Gate), Q12.3 (C), R16.2
unnamed: J5.A5 (Pin_9), J12.5 (Pin_6), Q16.3 (C), Q27.G (Gate), Q28.G (Gate), R65.2
unnamed: J5.A6 (Pin_11), J12.6 (Pin_7), Q17.3 (C), Q29.G (Gate), Q30.G (Gate), R66.2
unnamed: J5.A7 (Pin_13), J13.1, Q18.G (Gate), Q19.G (Gate), Q26.3 (C), R5.2
unnamed: J5.B1 (Pin_2), J13.2, Q33.G (Gate), Q34.G (Gate), Q35.3 (C), R9.2
unnamed: J15.10, R78.1
unnamed: J15.12, R76.2
unnamed: J3.1 (Pin_2), J22.A1 (Pin_1), R2.1
unnamed: JP1.1 (A), MO3.4 (+5V)
unnamed: F1.1, Q1.D (Drain), Q2.D (Drain)
unnamed: F2.1, Q3.D (Drain), Q4.D (Drain)
unnamed: F3.1, Q5.D (Drain), Q6.D (Drain)
unnamed: F4.1, Q7.D (Drain), Q8.D (Drain)
unnamed: Q9.1 (B), R28.1, R48.1
unnamed: Q10.1 (B), R29.1, R49.1
unnamed: Q11.1 (B), R30.1, R50.1
unnamed: Q12.1 (B), R31.1, R53.1
unnamed: Q13.1 (B), R26.1, R73.1
unnamed: Q14.1 (B), R4.1, R58.1
unnamed: Q15.1 (B), R7.1, R72.1
unnamed: Q16.1 (B), R47.1, R51.1
unnamed: Q17.1 (B), R45.1, R52.1
unnamed: F7.1, Q18.D (Drain), Q19.D (Drain)
unnamed: Q20.1 (B), R20.1, R71.1
unnamed: Q21.1 (B), R54.1, R59.1
unnamed: Q22.1 (B), R64.1, R67.1
unnamed: Q23.1 (B), R40.1, R42.1
unnamed: Q26.1 (B), R8.1, R43.1
unnamed: F5.1, Q27.D (Drain), Q28.D (Drain)
unnamed: F6.1, Q29.D (Drain), Q30.D (Drain)
unnamed: F8.1, Q33.D (Drain), Q34.D (Drain)
unnamed: Q35.1 (B), R11.1, R38.1
unnamed: R41.2, U5.2 (ALERT/RDY)
O_FRIGE: R26.2, U4.11 (IO_38)
O_INV: R20.2, U4.19 (IO_01)
O_TV: R7.2, U4.14 (IO_41)
PU DN: R54.2, U4.13 (IO_40)
PU UP: R4.2, U4.12 (IO_39)
PUMP-COIL: CON_2.10, D36.2 (K), K10.6, R69.1
PUMP-IN: CON_1.14, CON_2.9, F15.2, K10.14, R39.1
PUMP-OUT 1: CON_2.7, CON_2.8, K10.7
RO: R33.1, U2.1 (RO), U4.23 (IO_04)
SCL: MO2.SCL, R12.1, U4.18 (IO_2/SCL), U5.10 (SCL); also elsewhere on the board
SDA: MO2.SDA, R17.1, U4.15 (IO_42/SDA), U5.9 (SDA); also elsewhere on the board
SEAT-COIL-DIODE: CON_2.3, D38.2 (K)
SEAT-COIL-PLUS: CON_2.5, D28.2 (K), F14.2, K9.6, K9.14, R32.1, R70.1
SEAT-OUT: CON_3.11, K9.7
ST-7789V-CS: J8.3, J22.B3 (Pin_9), U4.30 (IO_18)
ST-7789V-D/C: J3.3 (Pin_4), J22.A3 (Pin_3), U4.36 (IO_09)
ST-7789V-RESET: J3.5 (Pin_6), J22.A5 (Pin_5), U4.34 (IO_03)
ST-7789V-SCL: J3.4 (Pin_5), J22.A4 (Pin_4), U4.35 (IO_46)
ST-7789V-SDA: J8.4, J22.B4 (Pin_10), U4.29 (IO_17)
ST-7789V-TP_SCL: J8.2, J22.B2 (Pin_8), U4.31 (IO_08)
ST-7789V-TP_SDA: J3.2 (Pin_3), J22.A2 (Pin_2), U4.37 (IO_10)
ST-7789V-TP_TINT: J3.6 (Pin_7), J22.A6 (Pin_6), U4.33 (IO_20)
ST-7789V-TP_TRST: J8.1, J22.B1 (Pin_7), U4.32 (IO_19)
SW-DOWN: CON_3.5, D30.1 (K), D34.1 (A), K6.2, Q21.3 (C)
SW-UP: CON_3.4, D29.1 (K), D33.1 (A), K3.2, Q14.3 (C)
TV: D12.1 (A), J5.B3 (Pin_6), J13.4, K4.2, Q15.3 (C)
WASTE: MO2.A2, U5.6 (AIN2)

Notes on the sheet:
Vds = -40V
ST7789V
COM
LED OUT 07
LED OUT 06
인체감지 센서
LED OUT 05
ADDRESS : 0x48
IO_01 : Full Up -> Boot Fail IO_13, 14 -> UnUse..

Board: 2 copper layers, 181.8 x 143.2 mm, 224 parts (104 on the bottom side), 146 nets.

Other parts of the board:
MO2#2: ADS1115_SMD

Their connections:
+5V: MO2#2.VCC; also elsewhere on the board
AUX-V: MO2#2.A0; also elsewhere on the board
CLEAN: MO2#2.A1; also elsewhere on the board
GNDPWR: MO2#2.GND; also elsewhere on the board
SCL: MO2#2.SCL; also elsewhere on the board
SDA: MO2#2.SDA; also elsewhere on the board
